# Keil uVision project KEIL_TMPM475SBK.uvprojx, settings and files
target TMPM475SBK (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPM475FDFG Toshiba
  pack: Keil.TMPM4_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20008000,0x00000800) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: KEIL_TMPM475SBK +hex
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c define: ARM_MATH_CM4 __FPU_PRESENT=1 KEIL_VER
  c include: ..\source\Libraries\TX04_CMSIS;..\source\Libraries\TX04_Periph_Driver\inc;..\source;..\source\Libraries\TX04_CMSIS\startup\arm
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20008000 size 0x800
  group Source
    ../source/: B_User.c C_Control.c calc.c D_Driver.c dac_drv.c E_Sub.c initial.c interrupt.c main.c mcuip_drv_ave.c system_int.c usercon.c nguyen_uart.c tmpm475_can_int.c nguyen_encoder.c nguyen_motor_app.c
  group Periph_Driver
    ../source/Libraries/TX04_Periph_Driver/src/: tmpm475_adc.c tmpm475_enc.c tmpm475_gpio.c tmpm475_tmrb.c tmpm475_uart.c tmpm475_wdt.c tmpm475_can.c
software components: CMSIS Driver:CAN:Custom 1.2.0, CMSIS:CORE 5.3.0, CMSIS:DSP 1.7.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 1.0.0
