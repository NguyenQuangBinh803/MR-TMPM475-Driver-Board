# IAR project Backup of TMPM475SK_rev10_pub.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TMPM475FDFG Toshiba TMPM475FDFG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\source\Libraries\TX04_CMSIS; ..\source\Libraries\TX04_Periph_Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: TMPM475SK_rev10_pub.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../source/: B_User.c B_User.h C_Control.c C_Control.h calc.c calc.h D_Driver.c D_Driver.h D_Para.h D_Para_ch0.h D_Para_ch1.h dac_drv.c dac_drv.h E_Sub.c E_Sub.h initial.c initial.h interrupt.c interrupt.h ipdefine.h main.c mcuip_drv_ave.c mcuip_drv_ave.h sys_macro.h system_int.c system_int.h usercon.c usercon.h
  group Libraries/TX04_CMSIS
    ../source/Libraries/TX04_CMSIS/startup/iar/: startup_TMPM475.s
    ../source/Libraries/TX04_CMSIS/: system_TMPM475.c system_TMPM475.h TMPM475.h
  group Libraries/TX04_Periph_Driver/inc
    ../source/Libraries/TX04_Periph_Driver/inc/: tmpm475_adc.h tmpm475_enc.h tmpm475_gpio.h tmpm475_tmrb.h tmpm475_uart.h tmpm475_wdt.h tx04_common.h
  group Libraries/TX04_Periph_Driver/src
    ../source/Libraries/TX04_Periph_Driver/src/: tmpm475_adc.c tmpm475_enc.c tmpm475_gpio.c tmpm475_tmrb.c tmpm475_uart.c tmpm475_wdt.c
