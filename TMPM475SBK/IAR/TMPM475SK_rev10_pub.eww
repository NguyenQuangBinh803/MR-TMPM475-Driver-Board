<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\TMPM475SK_rev10_pub.ewp</path>
  </project>
  <batchBuild/>
</workspace>


